# Keil uVision project TEST.uvprojx, settings and files
target MK60DN512 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60D10
  c misc: --c99
  c include: ..\CORE;..\FWLIB\inc;..\STARTUP;..\HARDWARE\OLED;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group STARTUP
    ../STARTUP/: system_MK60D10.c startup_MK60D10.s
  group FWLIB
    ../FWLIB/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group HARDWARE
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/: Control.c Key.c Menu.c Menu.h Key.h headfile.h Control.h Date.h
  group USER
    ../HARDWARE/: main.c
